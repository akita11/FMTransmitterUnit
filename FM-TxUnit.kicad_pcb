# Repository akita11/FMTransmitterUnit

File README.md:

# FM Transmitter Unit

FMラジオ用のトランスミッタ（ステレオ）です。
I2Cで送信周波数などを設定できます。
送信する音声信号は、3.5mmステレオジャックから与えてください。

※電波出力が弱いため（微弱無線機）、到達距離は数m程度です。受信側のアンテナを工夫することである程度到達距離を伸ばすことは可能です。

電波法上の微弱無線機の規格を満たしていることは確認済みで、測定データはMeasure/に提示してあります。
アンテナを変更したり、送信出力を大きくすると、電波法上の基準を超えて違法となる場合がありますので、ご注意ください。

## 使い方

Library/ 以下に、ArduinoIDEとPlatformIOで利用できるライブラリがありますので、活用してください。
それぞれの使い方は、Library/README.mdに記載してあります。

## Author

Junichi Akita (@akita11) / akita@ifdl.jp

## KiCad design FM-TxUnit.kicad_pcb

Parts:
C1: 10u; C_0603_1608Metric; LCSC C19702
C2, C3, C4, C7: 0.1u; C_0603_1608Metric; LCSC C14663
C5, C6: 15p; C_0603_1608Metric; LCSC C1644
C8, C9, C10: 33p; C_0603_1608Metric
C11, C13, C14: 100p; C_0603_1608Metric
C12: 0.1u; C_0603_1608Metric
CN1: CON_GROVE; CON_GROVE_H
CN2: PJ-3200; AUDIO-TH_PJ-3200; LCSC Part C2689690
D1: LED; D_0603_1608Metric
J1: ANT; ANT_Pad1.6_Drill0.9
L1, L2: 82n; L_0805_2012Metric
R1: 10k; R_0603_1608Metric
R2: R; R_0603_1608Metric
R3, R4: 4.7k; R_0603_1608Metric; LCSC C23162
U2: LDO_3p_GOI; SOT-23; LCSC C41376473
U3: KT0803L; JEITA_SOIC-16_3.9x9.9mm_P1.27mm
Y1: 32.768kHz; Crystal_SMD_3215-2Pin_3.2x1.5mm; LCSC C5447672

Connections:
+3V3: C1.1, C11.1, C12.1, R1.1, R3.1, R4.1, U2.2 (VO), U3.4 (VDDIO), U3.8 (SW1)
/ANT: C10.1, J1.1, L2.2
/AuduoL: C2.1, C13.1, CN2.4
/AuduoR: C4.1, C14.1, CN2.2
/PA_OUT: C8.1, L1.1, U3.16 (PA_OUT)
/RF_MID: C9.1, L1.2, L2.1
/RSTB: C7.1, R1.2, U3.10 (RSTB)
/SCL: CN1.1, R3.2, U3.14 (SCL)
/SDA: CN1.2, R4.2, U3.13 (SDA)
/XI: C5.2, U3.3 (XI), Y1.2
/XO: C6.2, U3.2 (XO), Y1.1
GND: C1.2, C3.2, C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, CN1.4, CN2.3, R2.2, U2.1 (GND), U3.1 (GND), U3.5 (GND), U3.9 (SW2), U3.11 (GND), U3.12 (GND), U3.15 (GND)
unnamed: D1.1 (K), R2.1
unnamed: C2.2, U3.6 (INL)
unnamed: C4.2, U3.7 (INR)
VDD: C3.1, CN1.3, D1.2 (A), U2.3 (VI)

Notes on the sheet:
高調波除去LPF（π型, 76〜95MHz送信用） C: C0G(NP0) 0603 / L: 巻線型 0805, SRF≧1GHz（例: Coilcraft 0805CS-820） L2・C10 は基板裏面（5次フィルタ評価用） 5次: L2=82nH, C10=33pF 実装 → 350MHz 約−48dB（C9=47pFにすると約−51dB） 3次: L2=0Ω(0805), C10=未実装 → 350MHz 約−27〜−33dB
U3 IOVDD デカップリング（pin4直近）

Board: 2 copper layers, 20.6 x 28.0 mm, 27 parts (2 on the bottom side), 16 nets.
